!Keysight Technologies,N5227A,US51270214,A.10.65.11
!Date: Thursday, October 15, 2020 07:46:40
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (one-way two-port):
!   201 points, 10 MHz to 60 GHz, reference 50 ohm
!   highest |S21| = -79.59 dB at 10 MHz (marker M1); lowest = -137.6 dB at 10.51 GHz (marker M2)
!   lowest |S11| = -72.8 dB at 8.409 GHz (marker M3), VSWR 1.00, Z = 50 + j0.0134 ohm
!   |S11| at or under -10 dB: 300.9 MHz to 29.43 GHz (29.13 GHz wide, 196 % of centre); 32.41 GHz to 43.2 GHz (10.79 GHz wide, 28.6 % of centre); 45.69 GHz to end of sweep
!   |S22| runs from -33.9 to -1.2 dB; largest |S21 - S12| = 0.00012
!   S11 on the Smith chart (normalised r, x): 10 MHz: 0, -14; 9.908 GHz: 0.81, +0.02; 39.6 GHz: 0.68, +0.17; 60 GHz: 0.90, -0.26
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -79.6  -88.6  -1.2
! 309.9 MHz  -10.3  -109.0  -119.4  -19.0
! 1.81 GHz  -29.8  -112.6  -110.7  -33.9
! 7.509 GHz  -23.8  -112.6  -110.1  -14.7
! 8.109 GHz  -35.4  -112.4  -111.5  -13.6
! 8.409 GHz  -72.8  -110.0  -116.7  -13.2
! 8.709 GHz  -36.8  -125.2  -110.6  -12.9
! 9.908 GHz  -19.4  -106.1  -111.6  -12.1
! 10.21 GHz  -17.5  -119.9  -108.4  -12.0
! 10.51 GHz  -16.3  -137.6  -107.1  -11.8
! 14.71 GHz  -28.9  -115.2  -134.8  -12.7
! 17.11 GHz  -12.7  -105.0  -105.7  -13.3
! 20.11 GHz  -20.0  -107.2  -100.6  -24.7
! 30 GHz  -9.4  -105.8  -107.8  -7.7
! 35.4 GHz  -22.9  -89.6  -91.7  -12.3
! 39.6 GHz  -13.5  -104.8  -91.8  -11.9
! 40.2 GHz  -11.5  -87.8  -94.9  -13.4
! 47.1 GHz  -21.5  -96.0  -89.8  -21.2
! 50.1 GHz  -13.8  -96.4  -94.1  -9.2
! 57.3 GHz  -11.7  -86.2  -91.5  -16.2
! 59.4 GHz  -27.9  -83.1  -80.3  -14.3
! 60 GHz  -16.9  -83.3  -93.8  -13.1
