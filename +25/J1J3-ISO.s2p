!Keysight Technologies,N5227A,US51270214,A.10.65.11
!Date: Thursday, October 15, 2020 07:32:33
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (one-way two-port):
!   200 points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, 309.9 MHz to 60 GHz, reference 50 ohm
!   highest |S21| = -79.59 dB at 60 GHz (marker M1); lowest = -131.4 dB at 22.21 GHz (marker M2)
!   lowest |S11| = -37.4 dB at 13.81 GHz (marker M3), VSWR 1.03, Z = 49.7 - j1.32 ohm
!   |S11| at or under -10 dB: start of sweep to 30.21 GHz; 32.25 GHz to 38.46 GHz (6.215 GHz wide, 17.6 % of centre); 43.81 GHz to 50.25 GHz (6.444 GHz wide, 13.7 % of centre) (the widest 3 of 5)
!   |S22| runs from -28.9 to -7.3 dB; largest |S21 - S12| = 0.00011
!   S11 on the Smith chart (normalised r, x): 309.9 MHz: 1.32, -0.53; 18.01 GHz: 1.01, -0.41; 28.51 GHz: 1.35, +0.03; 41.1 GHz: 0.50, +0.02; 60 GHz: 0.20, +0.00
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 309.9 MHz  -11.7  -111.8  -108.6  -14.4
! 2.11 GHz  -22.3  -117.0  -105.6  -28.4
! 6.609 GHz  -20.5  -107.6  -124.4  -25.5
! 7.809 GHz  -37.1  -110.3  -120.4  -22.1
! 10.51 GHz  -11.6  -107.8  -115.7  -18.6
! 12.91 GHz  -17.7  -116.3  -109.2  -16.3
! 13.81 GHz  -37.4  -114.9  -117.5  -15.8
! 15.01 GHz  -13.0  -107.4  -106.8  -14.5
! 18.01 GHz  -14.0  -111.9  -112.8  -12.6
! 20.41 GHz  -13.4  -114.1  -114.2  -19.7
! 22.21 GHz  -26.4  -131.4  -107.8  -23.2
! 24.61 GHz  -10.9  -103.2  -108.0  -13.2
! 28.51 GHz  -16.6  -100.3  -93.1  -12.0
! 30.3 GHz  -9.9  -97.6  -95.5  -11.5
! 34.8 GHz  -22.7  -99.1  -101.6  -15.3
! 40.2 GHz  -7.8  -91.9  -91.6  -24.5
! 41.1 GHz  -9.6  -90.3  -101.7  -14.6
! 48.6 GHz  -25.9  -96.3  -97.0  -12.8
! 50.1 GHz  -10.4  -94.3  -88.7  -9.8
! 52.8 GHz  -16.9  -92.3  -85.8  -9.9
! 53.7 GHz  -33.6  -94.3  -89.7  -12.2
! 60 GHz  -3.6  -79.6  -90.7  -17.4
